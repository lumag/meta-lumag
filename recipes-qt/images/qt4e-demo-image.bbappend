IMAGE_INSTALL += "${POKY_BASE_INSTALL}"
