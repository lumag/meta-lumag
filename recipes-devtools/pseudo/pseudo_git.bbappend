SRCREV = "060058bb29f70b244e685b3c704eb0641b736f73"
LIC_FILES_CHKSUM = "file://COPYING;md5=a1d8023a6f953ac6ea4af765ff62d574"
