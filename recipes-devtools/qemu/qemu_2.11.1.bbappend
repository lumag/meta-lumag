FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = "\
	file://184943d827ce09375284e6fbb9fd5eeb9e369529.patch \
	file://71ba74f67eaca21b0cc9d96f534ad3b9a7161400.patch \
"
