FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://fix-gettid.patch \
"
